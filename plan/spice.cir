.title KiCad schematic
U7 3.3V 3.3V 3.3V 3.3V 3.3V XShutDown 3.3V Net-_R14-Pad2_ /lvl /lvl 3.3V 3.3V VL53L0CXV0DH_1
U4 3.3V 3.3V 3.3V 3.3V 3.3V XShutDown 3.3V Net-_R6-Pad2_ /lvl /lvl 3.3V 3.3V VL53L0CXV0DH_1
U5 3.3V Net-_J3-Pad5_ Net-_J3-Pad6_ 3.3V 3.3V Net-_C3-Pad2_ 3.3V Net-_J3-Pad8_ 3.3V 3.3V Net-_C4-Pad2_ /lvl /lvl MPU-6050
Q1 3.3V /lvl HV BSS138
R3 /lvl 3.3V 10k
R1 HV HV 10k
Q2 3.3V /lvl HV BSS138
R4 /lvl 3.3V 10k
R2 HV HV 10k
Q4 3.3V /lvl HV BSS138
R12 /lvl 3.3V 10k
R11 HV HV 10k
U1 3.3V Net-_D1-Pad2_ Net-_D3-Pad2_ +7.5V /P2-1_PWM +5V /P6-0_PWM 3.3V +5V /P6-1_PWM +5V /P6-2_PWM Net-_D5-Pad2_ Net-_D7-Pad2_ NC_01 L298N
Q3 3.3V /lvl HV BSS138
R9 /lvl 3.3V 10k
R7 HV HV 10k
C4 3.3V Net-_C4-Pad2_ 2.2n
C3 3.3V Net-_C3-Pad2_ 0.1u
C2 3.3V 3.3V 0.01u
R14 3.3V Net-_R14-Pad2_ 10k
R5 XShutDown 3.3V 10k
R8 XShutDown 3.3V 10k
R13 3.3V Net-_R13-Pad2_ 10k
R6 3.3V Net-_R6-Pad2_ 10k
U6 3.3V 3.3V 3.3V 3.3V 3.3V XShutDown 3.3V Net-_R13-Pad2_ /lvl /lvl 3.3V 3.3V VL53L0CXV0DH_1
U3 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 3.3V NC_08 NC_09 NC_10 NC_11 3.3V NC_12 NC_13 3.3V NC_14 3.3V /lvl /lvl NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NodeMCU_1.0_(ESP-12E)
R10 XShutDown 3.3V 10k
J1 Net-_D1-Pad2_ Net-_D3-Pad2_ Conn_01x02_Female
J2 Net-_D5-Pad2_ Net-_D7-Pad2_ Conn_01x02_Female
D8 Net-_D7-Pad2_ 3.3V D
D6 Net-_D5-Pad2_ 3.3V D
D4 Net-_D3-Pad2_ 3.3V D
D2 Net-_D1-Pad2_ 3.3V D
D7 +7.5V Net-_D7-Pad2_ D
D5 +7.5V Net-_D5-Pad2_ D
D3 +7.5V Net-_D3-Pad2_ D
D1 +7.5V Net-_D1-Pad2_ D
C1 +7.5V 3.3V 220u
U2 NC_26 NC_27 NC_28 NC_29 NC_30 3.3V 3.3V NC_31 NC_32 NC_33 NC_34 HV HV NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 /P6-2_PWM /P6-1_PWM /P6-0_PWM NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 /P2-1_PWM NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 HV HV NC_59 NC_60 NC_61 NC_62 NC_63 MSP430FR2355TPT
J3 3.3V 3.3V /lvl /lvl Net-_J3-Pad5_ Net-_J3-Pad6_ 3.3V Net-_J3-Pad8_ Conn_01x08_Female
.end
